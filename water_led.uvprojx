# Keil uVision project water_led.uvprojx, settings and files
target STM32F103C8 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CLOCK(72000000) CPUTYPE("Cortex-M3")
  output: water_led +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 wLevel=3
  group CMSIS
    ./: startup_stm32f10x_md.s system_stm32f10x.c
  group User
    ./: main.c
